# Keil uVision project template.uvproj, settings and files
target tempate (ARM-ADS)
  device: AT32F422CBT7 ArteryTek
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x08000000-0x0801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M4") FPU2
  output: Template +hex
  c flags: Optim=1
  c define: AT32F422CBT7,USE_STDPERIPH_DRIVER,AT_START_F422_V1
  c include: ..\..\..\..\libraries\drivers\inc;..\..\..\..\libraries\cmsis\cm4\core_support;..\..\..\..\libraries\cmsis\cm4\device_support;..\inc;..\..\..\at32f422_426_board
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group user
    ../src/: at32f422_426_int.c at32f422_426_clock.c main.c
  group bsp
    ../../../at32f422_426_board/: at32f422_426_board.c
  group cmsis
    ../../../../libraries/cmsis/cm4/device_support/startup/mdk/: startup_at32f422_426.s
    ../../../../libraries/cmsis/cm4/device_support/: system_at32f422_426.c
  group firmware
    ../../../../libraries/drivers/src/: at32f422_426_adc.c at32f422_426_can.c at32f422_426_cmp.c at32f422_426_crc.c at32f422_426_crm.c at32f422_426_debug.c at32f422_426_dma.c at32f422_426_ertc.c at32f422_426_exint.c at32f422_426_flash.c at32f422_426_gpio.c at32f422_426_i2c.c at32f422_426_misc.c at32f422_426_pwc.c at32f422_426_scfg.c at32f422_426_spi.c at32f422_426_tmr.c at32f422_426_usart.c at32f422_426_wdt.c at32f422_426_wwdt.c
  group readme
    ../: readme.txt
