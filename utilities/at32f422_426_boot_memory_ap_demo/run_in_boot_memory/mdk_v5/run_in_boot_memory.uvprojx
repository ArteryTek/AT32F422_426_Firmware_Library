# Keil uVision project run_in_boot_memory.uvprojx, settings and files
target run_in_boot_memory_at32f422 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: AT32F422CBT7 ArteryTek
  pack: ArteryTek.AT32F422_426_DFP.2.0.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: run_in_boot_memory_at32f422 +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AT32F422CBT7,USE_STDPERIPH_DRIVER,AT_START_F422_V1
  c include: ..\..\..\..\project\at32f422_426_board;..\..\..\..\libraries\drivers\inc;..\..\..\..\libraries\cmsis\cm4\device_support;..\..\..\..\libraries\cmsis\cm4\core_support;..\inc
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT5: ROM 0x1fff8000 size 0x7000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group user
    ../src/: at32f422_426_clock.c at32f422_426_int.c main.c run_in_boot_memory.c
  group bsp
    ../../../../project/at32f422_426_board/: at32f422_426_board.c
  group firmware
    ../../../../libraries/drivers/src/: at32f422_426_crm.c at32f422_426_gpio.c at32f422_426_usart.c at32f422_426_misc.c
  group cmsis
    ../../../../libraries/cmsis/cm4/device_support/startup/mdk/: startup_at32f422_426.s
    ../../../../libraries/cmsis/cm4/device_support/: system_at32f422_426.c
  group readme
    ../: readme.txt
target run_in_boot_memory_at32f426 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: AT32F426CBT7 ArteryTek
  pack: ArteryTek.AT32F422_426_DFP.2.0.0
  cpu: as above
  output: run_in_boot_memory_at32f426 +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AT32F426CBT7,USE_STDPERIPH_DRIVER,AT_START_F426_V1
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT5: ROM 0x1fff8000 size 0x7000
  memory RVCT9: RAM 0x20000000 size 0x5000
