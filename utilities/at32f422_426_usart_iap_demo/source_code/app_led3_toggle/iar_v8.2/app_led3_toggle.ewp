# IAR project app_led3_toggle.ewp, settings and files
configuration app_led3_toggle_at32f422 (ARM, debug)
  General.OGChipSelectEditMenu: AT32F422CBT7_v2 ArteryTek AT32F422CBT7
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: AT32F422CBT7; USE_STDPERIPH_DRIVER; AT_START_F422_V1
  ICCARM.CCIncludePath2: ..\..\..\..\..\libraries\drivers\inc; ..\..\..\..\..\libraries\cmsis\cm4\core_support; ..\..\..\..\..\libraries\cmsis\cm4\device_support; ..\inc; ..\..\..\..\..\project\at32f422_426_board
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: app_led3_toggle.bin
  ILINK.IlinkOutputFile: app_led3_toggle.out
  ILINK.IlinkIcfFile: AT32F422xB.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration app_led3_toggle_at32f426 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: AT32F426CBT7_v2 ArteryTek AT32F426CBT7
  ICCARM.CCDefines: AT32F426CBT7; USE_STDPERIPH_DRIVER; AT_START_F426_V1
  ILINK.IlinkIcfFile: AT32F426xB.icf
  group bsp
    ../../../../../project/at32f422_426_board/: at32f422_426_board.c
  group cmsis
    ../../../../../libraries/cmsis/cm4/device_support/startup/iar/: startup_at32f422_426.s
    ../../../../../libraries/cmsis/cm4/device_support/: system_at32f422_426.c
  group firmware
    ../../../../../libraries/drivers/src/: at32f422_426_crm.c at32f422_426_flash.c at32f422_426_gpio.c at32f422_426_misc.c at32f422_426_tmr.c at32f422_426_usart.c
  group readme
    ../: readme.txt
  group user
    ../src/: at32f422_426_clock.c at32f422_426_int.c iap.c main.c tmr.c usart.c
