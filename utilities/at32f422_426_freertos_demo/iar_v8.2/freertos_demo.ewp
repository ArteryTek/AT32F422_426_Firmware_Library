# IAR project freertos_demo.ewp, settings and files
configuration freertos_demo_at32f422 (ARM)
  General.OGChipSelectEditMenu: AT32F422CBT7_v2 ArteryTek AT32F422CBT7
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: AT_START_F422_V1; AT32F422CBT7
  ICCARM.CCIncludePath2: ..\..\..\libraries\drivers\inc; ..\..\..\libraries\cmsis\cm4\core_support; ..\..\..\libraries\cmsis\cm4\device_support; ..\..\..\middlewares\freertos\source\include; ..\..\..\middlewares\freertos\source\portable\IAR\ARM_CM4F; ..\inc; ..\..\..\project\at32f422_426_board
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\..\..\middlewares\freertos\source\portable\IAR\ARM_CM4F; ..\inc
  OBJCOPY.OOCOutputFile: freertos_demo.hex
  ILINK.IlinkOutputFile: freertos_demo.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration freertos_demo_at32f426 (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: AT32F426CBT7_v2 ArteryTek AT32F426CBT7
  ICCARM.CCDefines: AT_START_F426_V1; AT32F426CBT7
  group bsp
    ../../../project/at32f422_426_board/: at32f422_426_board.c
  group cmsis
    ../../../libraries/cmsis/cm4/device_support/startup/iar/: startup_at32f422_426.s
    ../../../libraries/cmsis/cm4/device_support/: system_at32f422_426.c
  group firmware
    ../../../libraries/drivers/src/: at32f422_426_adc.c at32f422_426_cmp.c at32f422_426_crc.c at32f422_426_crm.c at32f422_426_debug.c at32f422_426_dma.c at32f422_426_ertc.c at32f422_426_exint.c at32f422_426_flash.c at32f422_426_gpio.c at32f422_426_i2c.c at32f422_426_misc.c at32f422_426_pwc.c at32f422_426_scfg.c at32f422_426_spi.c at32f422_426_tmr.c at32f422_426_usart.c at32f422_426_wdt.c at32f422_426_wwdt.c
  group freertos
    ../../../middlewares/freertos/source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../../middlewares/freertos/source/portable/memmang/: heap_4.c
    ../../../middlewares/freertos/source/portable/IAR/ARM_CM4F/: port.c portasm.s
  group readme
    ../: readme.txt
  group user
    ../src/: at32f422_426_clock.c at32f422_426_int.c main.c
